KV = "4.11.0"
SRCDATE = "20170915"
MODNAMES = "brcmstb-${MACHINE} ci ftm4862 fts260 sp988x"

require spycat-dvb-modules.inc

COMPATIBLE_MACHINE = "spycatminiplus"

SRC_URI[md5sum] = "e5230c8cb5692e7785aa91fcd28035e1"
SRC_URI[sha256sum] = "9349d1e195046e4d24628db2c373344f644344bceeae26d60b977ce74e6fdbc1"
