KV = "4.11.0"
SRCDATE = "20170915"
MODNAMES = "brcmstb-${MACHINE} ci ftm4862 fts260 sp988x"

require spycat-dvb-modules.inc

COMPATIBLE_MACHINE = "spycat"

SRC_URI[md5sum] = "4e665f01f4a8739dfa0c5e35f1a451f2"
SRC_URI[sha256sum] = "4e4805cf876619e434631140f37f2a8e898db030ec9fb4d16226e139a2442cdb"
